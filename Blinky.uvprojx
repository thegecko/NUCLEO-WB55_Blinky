# Keil uVision project Blinky.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x000040000) IROM(0x08000000,0x001000000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
  group Source Group 1
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32WB55RGVx/STCubeGenerated/Src/: main.c stm32wbxx_it.c
    ./RTE/Device/STM32WB55RGVx/STCubeGenerated/Inc/: stm32wbxx_it.h
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: Blinky
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube HAL:Common 1.8.0, Device:STM32Cube HAL:Cortex 1.8.0, Device:STM32Cube HAL:GPIO 1.8.0, Device:STM32Cube HAL:PWR 1.8.0, Device:STM32Cube HAL:RCC 1.8.0, Device:Startup 1.0.0
